<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Chassis-motor-driver-c8t6.ewp</path>
  </project>
  <batchBuild />
</workspace>
